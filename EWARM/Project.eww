<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32f030_uart_overrun.ewp</path>
  </project>
  <batchBuild />
</workspace>
